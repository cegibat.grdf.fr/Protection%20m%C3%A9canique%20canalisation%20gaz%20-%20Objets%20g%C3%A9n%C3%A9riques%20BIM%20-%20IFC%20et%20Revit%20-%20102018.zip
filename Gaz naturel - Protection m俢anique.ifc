Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:18:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:18:54 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{D0A6C9E5-DE86-458F-96C4-0FEC889355D9}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:18:52 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:18:52 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:18:52 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: Gaz naturel – Protection mécanique, Gaz naturel – Protection mécanique:Gaz naturel – Protection mécanique:206340
In: Niveau 1
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Protection mécanique
Type - Contraintes(Type) - Elévation par défaut: 0 mm
Type - Données d'identification(Type) - Nom du type: Gaz naturel – Protection mécanique
Pset_DistributionFlowElementCommon - Reference: Gaz naturel – Protection mécanique
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Protection mécanique: Gaz naturel – Protection mécanique; Famille et type: Gaz naturel – Protection mécanique: Gaz naturel – Protection mécanique; ID du type: Gaz naturel – Protection mécanique: Gaz naturel – Protection mécanique; Niveau de nomenclature: Niveau: Niveau 1; Type: Gaz naturel – Protection mécanique: Gaz naturel – Protection mécanique
Contraintes - Décalage: 0 mm; Largeur: 60 mm; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Longueur: 1000 mm; Matériau: Gris; Niveau: Niveau: Niveau 1
Cotes - Débort: 9 mm; Epaisseure: 3 mm; Largeur 2: 66 mm; Surface: 0.120311 m2; Volume: 0.000350866 m3
Données d'identification - Identifiant: 20
Isolation - Epaisseur d'isolation: 0 mm
Phase de construction - Phase de création: Nouvelle construction
